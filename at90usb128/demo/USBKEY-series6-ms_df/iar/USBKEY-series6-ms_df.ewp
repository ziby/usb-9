# IAR project USBKEY-series6-ms_df.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: Pe111,Pe550
  ICCAVR.newCCIncludePaths: ..; ../conf/; ../../../; ../../../../common/
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgusb1286.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../modules/control_access/: ctrl_access.c
    ../../../lib_mem/df/: df.c df_mem.c
    ../: main.c storage_task.c usb_descriptors.c usb_specific_request.c
    ../../../lib_mcu/power/: power_drv.c
    ../../../../common/modules/scheduler/: scheduler.c
    ../../../modules/scsi_decoder/: scsi_decoder.c
    ../../../modules/usb/device_chap9/: usb_device_task.c usb_standard_request.c
    ../../../lib_mcu/usb/: usb_drv.c
    ../../../modules/usb/: usb_task.c
    ../../../../common/lib_mcu/wdt/: wdt_drv.c
